# Keil uVision project AT32F421F8P7_WorkBench.uvprojx, settings and files
target AT32F421F8P7_WorkBench (6230000::V6.23::ARMCLANG)
  device: -AT32F421F8P7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421F8P7_WorkBench +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: C:\Users\Administrator\Desktop\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F421F8P7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\app;..\device;..\inc;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_usart.c wk_gpio.c wk_tmr.c wk_crc.c wk_wdt.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_debug.c at32f421_flash.c at32f421_crc.c at32f421_wdt.c at32f421_misc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group device
    ../device/: tmt.c iap_usart.c flash.c
  group app
    ../app/: flash_handle.c 433_receiver.c iap.c asrpro_handle.c usart_send_handle.c FW433_handle.c
